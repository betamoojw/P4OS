/*
 * PINBALL - the dot-matrix display (see pb_dmd.h)
 */
#include "pb_dmd.h"

#include "pb_table.h"

#include <string.h>

/* 5 x 7, a row a byte, bit 4 the left dot: ' ' (32) to 'Z' (90) */
static const uint8_t FONT[59][7] = {
    { 0, 0, 0, 0, 0, 0, 0 },                            /*   */
    { 0x04, 0x04, 0x04, 0x04, 0x04, 0x00, 0x04 },       /* ! */
    { 0x0A, 0x0A, 0, 0, 0, 0, 0 },                      /* " */
    { 0x0A, 0x1F, 0x0A, 0x0A, 0x1F, 0x0A, 0x00 },       /* # */
    { 0x04, 0x0F, 0x14, 0x0E, 0x05, 0x1E, 0x04 },       /* $ */
    { 0x18, 0x19, 0x02, 0x04, 0x08, 0x13, 0x03 },       /* % */
    { 0x0C, 0x12, 0x14, 0x08, 0x15, 0x12, 0x0D },       /* & */
    { 0x04, 0x04, 0, 0, 0, 0, 0 },                      /* ' */
    { 0x02, 0x04, 0x08, 0x08, 0x08, 0x04, 0x02 },       /* ( */
    { 0x08, 0x04, 0x02, 0x02, 0x02, 0x04, 0x08 },       /* ) */
    { 0x00, 0x04, 0x15, 0x0E, 0x15, 0x04, 0x00 },       /* * */
    { 0x00, 0x04, 0x04, 0x1F, 0x04, 0x04, 0x00 },       /* + */
    { 0, 0, 0, 0, 0x0C, 0x04, 0x08 },                   /* , */
    { 0, 0, 0, 0x1F, 0, 0, 0 },                         /* - */
    { 0, 0, 0, 0, 0, 0x0C, 0x0C },                      /* . */
    { 0x01, 0x01, 0x02, 0x04, 0x08, 0x10, 0x10 },       /* / */
    { 0x0E, 0x11, 0x13, 0x15, 0x19, 0x11, 0x0E },       /* 0 */
    { 0x04, 0x0C, 0x04, 0x04, 0x04, 0x04, 0x0E },       /* 1 */
    { 0x0E, 0x11, 0x01, 0x02, 0x04, 0x08, 0x1F },       /* 2 */
    { 0x1F, 0x02, 0x04, 0x02, 0x01, 0x11, 0x0E },       /* 3 */
    { 0x02, 0x06, 0x0A, 0x12, 0x1F, 0x02, 0x02 },       /* 4 */
    { 0x1F, 0x10, 0x1E, 0x01, 0x01, 0x11, 0x0E },       /* 5 */
    { 0x06, 0x08, 0x10, 0x1E, 0x11, 0x11, 0x0E },       /* 6 */
    { 0x1F, 0x01, 0x02, 0x04, 0x08, 0x08, 0x08 },       /* 7 */
    { 0x0E, 0x11, 0x11, 0x0E, 0x11, 0x11, 0x0E },       /* 8 */
    { 0x0E, 0x11, 0x11, 0x0F, 0x01, 0x02, 0x0C },       /* 9 */
    { 0, 0x0C, 0x0C, 0, 0x0C, 0x0C, 0 },                /* : */
    { 0, 0x0C, 0x0C, 0, 0x0C, 0x04, 0x08 },             /* ; */
    { 0x02, 0x04, 0x08, 0x10, 0x08, 0x04, 0x02 },       /* < */
    { 0, 0, 0x1F, 0, 0x1F, 0, 0 },                      /* = */
    { 0x08, 0x04, 0x02, 0x01, 0x02, 0x04, 0x08 },       /* > */
    { 0x0E, 0x11, 0x01, 0x02, 0x04, 0x00, 0x04 },       /* ? */
    { 0x0E, 0x11, 0x01, 0x0D, 0x15, 0x15, 0x0E },       /* @ */
    { 0x0E, 0x11, 0x11, 0x11, 0x1F, 0x11, 0x11 },       /* A */
    { 0x1E, 0x11, 0x11, 0x1E, 0x11, 0x11, 0x1E },       /* B */
    { 0x0E, 0x11, 0x10, 0x10, 0x10, 0x11, 0x0E },       /* C */
    { 0x1C, 0x12, 0x11, 0x11, 0x11, 0x12, 0x1C },       /* D */
    { 0x1F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x1F },       /* E */
    { 0x1F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x10 },       /* F */
    { 0x0E, 0x11, 0x10, 0x17, 0x11, 0x11, 0x0F },       /* G */
    { 0x11, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11 },       /* H */
    { 0x0E, 0x04, 0x04, 0x04, 0x04, 0x04, 0x0E },       /* I */
    { 0x07, 0x02, 0x02, 0x02, 0x02, 0x12, 0x0C },       /* J */
    { 0x11, 0x12, 0x14, 0x18, 0x14, 0x12, 0x11 },       /* K */
    { 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F },       /* L */
    { 0x11, 0x1B, 0x15, 0x15, 0x11, 0x11, 0x11 },       /* M */
    { 0x11, 0x11, 0x19, 0x15, 0x13, 0x11, 0x11 },       /* N */
    { 0x0E, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E },       /* O */
    { 0x1E, 0x11, 0x11, 0x1E, 0x10, 0x10, 0x10 },       /* P */
    { 0x0E, 0x11, 0x11, 0x11, 0x15, 0x12, 0x0D },       /* Q */
    { 0x1E, 0x11, 0x11, 0x1E, 0x14, 0x12, 0x11 },       /* R */
    { 0x0F, 0x10, 0x10, 0x0E, 0x01, 0x01, 0x1E },       /* S */
    { 0x1F, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04 },       /* T */
    { 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E },       /* U */
    { 0x11, 0x11, 0x11, 0x11, 0x11, 0x0A, 0x04 },       /* V */
    { 0x11, 0x11, 0x11, 0x15, 0x15, 0x15, 0x0A },       /* W */
    { 0x11, 0x11, 0x0A, 0x04, 0x0A, 0x11, 0x11 },       /* X */
    { 0x11, 0x11, 0x11, 0x0A, 0x04, 0x04, 0x04 },       /* Y */
    { 0x1F, 0x01, 0x02, 0x04, 0x08, 0x10, 0x1F },       /* Z */
};

/* the letters past ASCII, as code points */
static const struct {
    uint16_t cp;
    uint8_t  g[7];
} EXTRA[] = {
    { 0xC1, { 0x02, 0x04, 0x0E, 0x11, 0x1F, 0x11, 0x11 } },    /* Á */
    { 0xC9, { 0x02, 0x04, 0x1F, 0x10, 0x1E, 0x10, 0x1F } },    /* É */
    { 0xCD, { 0x02, 0x04, 0x0E, 0x04, 0x04, 0x04, 0x0E } },    /* Í */
    { 0xD3, { 0x02, 0x04, 0x0E, 0x11, 0x11, 0x11, 0x0E } },    /* Ó */
    { 0xDA, { 0x02, 0x04, 0x11, 0x11, 0x11, 0x11, 0x0E } },    /* Ú */
    { 0xD1, { 0x0D, 0x12, 0x11, 0x19, 0x15, 0x13, 0x11 } },    /* Ñ */
    { 0xDC, { 0x0A, 0x00, 0x11, 0x11, 0x11, 0x11, 0x0E } },    /* Ü */
    { 0xC4, { 0x0A, 0x00, 0x0E, 0x11, 0x1F, 0x11, 0x11 } },    /* Ä */
    { 0xD6, { 0x0A, 0x00, 0x0E, 0x11, 0x11, 0x11, 0x0E } },    /* Ö */
    { 0xA1, { 0x04, 0x00, 0x04, 0x04, 0x04, 0x04, 0x04 } },    /* ¡ */
    { 0xBF, { 0x04, 0x00, 0x04, 0x08, 0x10, 0x11, 0x0E } },    /* ¿ */
    { 0xB7, { 0, 0, 0, 0x04, 0, 0, 0 } },                      /* · */
};

static uint32_t next_cp(const char **s)
{
    const uint8_t *p = (const uint8_t *)*s;
    uint32_t c = *p++;
    if (c >= 0xC0 && c < 0xE0 && (*p & 0xC0) == 0x80) {
        c = ((c & 0x1F) << 6) | (*p++ & 0x3F);
    } else if (c >= 0xE0 && c < 0xF0 && (p[0] & 0xC0) == 0x80 && (p[1] & 0xC0) == 0x80) {
        c = ((c & 0x0F) << 12) | ((uint32_t)(p[0] & 0x3F) << 6) | (p[1] & 0x3F);
        p += 2;
    } else if (c >= 0xF0) {
        while ((*p & 0xC0) == 0x80) p++;
        c = '?';
    }
    *s = (const char *)p;
    return c;
}

/* the glyph of a code point, capitals for small letters; NULL: none */
static const uint8_t *glyph(uint32_t c)
{
    if (c >= 'a' && c <= 'z') c -= 32;
    if (c >= 0xE0 && c <= 0xFE && c != 0xF7) c -= 32;   /* á -> Á, ñ -> Ñ ... */
    if (c >= 32 && c <= 'Z') return FONT[c - 32];
    for (unsigned i = 0; i < sizeof EXTRA / sizeof EXTRA[0]; i++) {
        if (EXTRA[i].cp == c) return EXTRA[i].g;
    }
    /* letters without a glyph of their own */
    if (c >= 0xC0 && c <= 0xC5) return FONT['A' - 32];
    if (c >= 0xC8 && c <= 0xCB) return FONT['E' - 32];
    if (c >= 0xCC && c <= 0xCF) return FONT['I' - 32];
    if (c >= 0xD2 && c <= 0xD6) return FONT['O' - 32];
    if (c >= 0xD9 && c <= 0xDC) return FONT['U' - 32];
    if (c == 0xC7) return FONT['C' - 32];
    return NULL;
}

void dmd_clear(pb_dmd_t *d)
{
    memset(d->px, 0, sizeof d->px);
}

static void dot(pb_dmd_t *d, int x, int y, int level)
{
    if (x < 0 || y < 0 || x >= DMD_W || y >= DMD_H) return;
    d->px[y][x] = (uint8_t)level;
}

int dmd_text_w(const char *s, int scale)
{
    int w = 0;
    while (*s) {
        uint32_t c = next_cp(&s);
        if (c == 0xDF) w += 12;          /* ß: SS */
        else if (c == ',' || c == '.' || c == '\'' || c == '!' || c == 0xA1 || c == ':') w += 3;
        else w += 6;
    }
    return (w ? w - 1 : 0) * scale;
}

static int put_glyph(pb_dmd_t *d, int x, int y, const uint8_t *g, int scale, int level, int narrow)
{
    /* narrow punctuation sits in its two middle columns */
    int x0 = narrow ? 1 : 0, w = narrow ? 2 : 5;
    for (int r = 0; r < 7; r++) {
        for (int c = 0; c < w; c++) {
            if (!(g[r] & (0x10 >> (c + x0)))) continue;
            for (int sy = 0; sy < scale; sy++) {
                for (int sx = 0; sx < scale; sx++) dot(d, x + c * scale + sx, y + r * scale + sy, level);
            }
        }
    }
    return (w + 1) * scale;
}

void dmd_text(pb_dmd_t *d, int x, int y, const char *s, int scale, int level)
{
    while (*s) {
        uint32_t c = next_cp(&s);
        if (c == 0xDF) {
            x += put_glyph(d, x, y, FONT['S' - 32], scale, level, 0);
            x += put_glyph(d, x, y, FONT['S' - 32], scale, level, 0);
            continue;
        }
        const uint8_t *g = glyph(c);
        if (!g) g = FONT['?' - 32];
        int narrow = c == ',' || c == '.' || c == '\'' || c == '!' || c == 0xA1 || c == ':';
        x += put_glyph(d, x, y, g, scale, level, narrow);
    }
}

void dmd_text_c(pb_dmd_t *d, int y, const char *s, int scale, int level, int shift)
{
    int w = dmd_text_w(s, scale);
    if (w <= DMD_W) {
        dmd_text(d, (DMD_W - w) / 2, y, s, scale, level);
        return;
    }
    /* too wide: it scrolls through, with a gap before it comes round */
    int span = w + 32;
    int off = shift % span;
    dmd_text(d, DMD_W - off, y, s, scale, level);
    dmd_text(d, DMD_W - off + span, y, s, scale, level);
}

void dmd_rect(pb_dmd_t *d, int x, int y, int w, int h, int level)
{
    for (int j = y; j < y + h; j++) {
        for (int i = x; i < x + w; i++) dot(d, i, j, level);
    }
}

void dmd_frame(pb_dmd_t *d, int x, int y, int w, int h, int level)
{
    for (int i = x; i < x + w; i++) {
        dot(d, i, y, level);
        dot(d, i, y + h - 1, level);
    }
    for (int j = y; j < y + h; j++) {
        dot(d, x, j, level);
        dot(d, x + w - 1, j, level);
    }
}

void dmd_number(char *out, int n, uint32_t v)
{
    char tmp[16];
    int k = 0;
    do {
        tmp[k++] = (char)('0' + v % 10);
        v /= 10;
    } while (v && k < 15);
    char sep = pb_lang() == 1 ? ',' : '.';
    int o = 0;
    for (int i = k - 1; i >= 0 && o < n - 1; i--) {
        tmp[i] = tmp[i];
        out[o++] = tmp[i];
        if (i && i % 3 == 0 && o < n - 1) out[o++] = sep;
    }
    out[o] = 0;
}
